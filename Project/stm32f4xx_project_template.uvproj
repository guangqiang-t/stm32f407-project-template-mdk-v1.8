# Keil uVision project stm32f4xx_project_template.uvproj, settings and files
target STM32F4xxTemplate (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4xx_project_template
  c flags: Optim=2 oTime=1
  c define: STM32F40XX,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\BSP;..\OS;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Library
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group BSP
    ../BSP/: bsp_usart1.c bsp_delay.c
  group User
    ../User/: main.c stm32f4xx_conf.h
  group Doc
    ../: README.md
